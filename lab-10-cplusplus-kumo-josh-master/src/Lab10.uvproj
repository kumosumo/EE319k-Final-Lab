# Keil uVision project Lab10.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: Lab10
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./Display/: Display.cpp ST7735.cpp
    ./: main.cpp startup_TM4C123.s
    ./Input/: Input.cpp
    ./Obj/: Level.cpp Marble.cpp
    ./Time/: Time.cpp PLL.cpp Timer0.cpp Timer1.cpp Timer3.cpp Timer2.cpp
    ./Math/: Physics.cpp
    ./DAC/: dac.cpp
